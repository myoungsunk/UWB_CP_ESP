#line 1 "C:\\UWB\\UWB_R04_R1J6_FIELD_FIX_20261010\\R1M_CTRL_V2_RC1\\built\\sketches\\ANCHOR_RF_PLATFORM_V1\\remote_compact.hpp"
#pragma once
// Schema 2: explicit little-endian 479-byte encoding. No C++ padding on disk.
// ESP times use signed offsets from begin_us, with INT32_MIN reserved for absent(0).
// Out-of-domain values are rejected, never truncated. Full failure/air bytes retained.
constexpr size_t REMOTE_COMPACT_BYTES=479;
struct RemoteCompactRecord { uint8_t data[REMOTE_COMPACT_BYTES]{}; };
struct RemoteCodec {
 uint8_t* out; const uint8_t* in; size_t pos=0; bool ok=true;
 void put(uint64_t v,unsigned n){if(pos+n>REMOTE_COMPACT_BYTES){ok=false;return;}for(unsigned i=0;i<n;i++)out[pos++]=uint8_t(v>>(8*i));}
 uint64_t get(unsigned n){if(pos+n>REMOTE_COMPACT_BYTES){ok=false;return 0;}uint64_t v=0;for(unsigned i=0;i<n;i++)v|=uint64_t(in[pos++])<<(8*i);return v;}
 void delta(uint64_t v,uint64_t base){
  if(!v){put(0x80000000UL,4);return;}
  if((v>=base?v-base:base-v)>2147483647ULL){ok=false;return;}
  int64_t d=v>=base?int64_t(v-base):-int64_t(base-v);put(uint32_t(int32_t(d)),4);
 }
 uint64_t time(uint64_t base){uint32_t bits=uint32_t(get(4));if(bits==0x80000000UL)return 0;
  int64_t d=bits<=0x7fffffffUL?int64_t(bits):int64_t(bits)-4294967296LL;
  if((d<0&&base<uint64_t(-d))||(d>0&&base>UINT64_MAX-uint64_t(d))){ok=false;return 0;}
  uint64_t v=d<0?base-uint64_t(-d):base+uint64_t(d);if(!v)ok=false;return v;
 }
};
static bool remoteEncode(const RemoteAnchorRecord& s,RemoteCompactRecord& dst){
 RemoteCodec c{dst.data,nullptr};
 if(s.ntx>4||s.nrx>1||s.ok>1||s.fast_valid>1||s.response.received>1||s.response.diag>1||s.response.lde_done>1)return false;
 c.put(uint64_t(s.txn),4);
 c.put(uint64_t(s.begin_us),8);
 c.delta(s.end_us,s.begin_us);
 c.put(uint64_t(s.ntx),1);
 c.put(uint64_t(s.nrx),1);
 c.put(uint64_t(s.tx[0].type),1);
 c.put(uint64_t(s.tx[0].ctrl),1);
 c.put(uint64_t(s.tx[0].ls),1);
 c.put(uint64_t(s.tx[0].bytes),2);
 c.put(uint64_t(s.tx[0].ok),1);
 if(s.tx[0].planned>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[0].planned),5);
 if(s.tx[0].actual>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[0].actual),5);
 if(s.tx[0].status>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[0].status),5);
 c.delta(s.tx[0].begin_us,s.begin_us);
 c.delta(s.tx[0].done_us,s.begin_us);
 c.put(uint64_t(s.tx[0].lead_start_us),4);
 c.put(uint64_t(s.tx[0].lead_arm_us),4);
 c.put(uint64_t(s.tx[0].tx_delta_ticks),4);
 c.put(uint64_t(s.tx[0].prepare_us),4);
 c.put(uint64_t(s.tx[0].wait_us),4);
 c.put(uint64_t(s.tx[0].power_atten_x2),1);
 c.put(uint64_t(s.tx[0].power_octet),1);
 c.put(uint64_t(s.tx[0].power_reg),4);
 c.put(uint64_t(s.tx[0].power_read),4);
 c.put(uint64_t(s.tx[0].power_ok),1);
 c.put(uint64_t(s.tx[0].power_apply_us),4);
 c.put(uint64_t(s.tx[1].type),1);
 c.put(uint64_t(s.tx[1].ctrl),1);
 c.put(uint64_t(s.tx[1].ls),1);
 c.put(uint64_t(s.tx[1].bytes),2);
 c.put(uint64_t(s.tx[1].ok),1);
 if(s.tx[1].planned>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[1].planned),5);
 if(s.tx[1].actual>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[1].actual),5);
 if(s.tx[1].status>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[1].status),5);
 c.delta(s.tx[1].begin_us,s.begin_us);
 c.delta(s.tx[1].done_us,s.begin_us);
 c.put(uint64_t(s.tx[1].lead_start_us),4);
 c.put(uint64_t(s.tx[1].lead_arm_us),4);
 c.put(uint64_t(s.tx[1].tx_delta_ticks),4);
 c.put(uint64_t(s.tx[1].prepare_us),4);
 c.put(uint64_t(s.tx[1].wait_us),4);
 c.put(uint64_t(s.tx[1].power_atten_x2),1);
 c.put(uint64_t(s.tx[1].power_octet),1);
 c.put(uint64_t(s.tx[1].power_reg),4);
 c.put(uint64_t(s.tx[1].power_read),4);
 c.put(uint64_t(s.tx[1].power_ok),1);
 c.put(uint64_t(s.tx[1].power_apply_us),4);
 c.put(uint64_t(s.tx[2].type),1);
 c.put(uint64_t(s.tx[2].ctrl),1);
 c.put(uint64_t(s.tx[2].ls),1);
 c.put(uint64_t(s.tx[2].bytes),2);
 c.put(uint64_t(s.tx[2].ok),1);
 if(s.tx[2].planned>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[2].planned),5);
 if(s.tx[2].actual>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[2].actual),5);
 if(s.tx[2].status>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[2].status),5);
 c.delta(s.tx[2].begin_us,s.begin_us);
 c.delta(s.tx[2].done_us,s.begin_us);
 c.put(uint64_t(s.tx[2].lead_start_us),4);
 c.put(uint64_t(s.tx[2].lead_arm_us),4);
 c.put(uint64_t(s.tx[2].tx_delta_ticks),4);
 c.put(uint64_t(s.tx[2].prepare_us),4);
 c.put(uint64_t(s.tx[2].wait_us),4);
 c.put(uint64_t(s.tx[2].power_atten_x2),1);
 c.put(uint64_t(s.tx[2].power_octet),1);
 c.put(uint64_t(s.tx[2].power_reg),4);
 c.put(uint64_t(s.tx[2].power_read),4);
 c.put(uint64_t(s.tx[2].power_ok),1);
 c.put(uint64_t(s.tx[2].power_apply_us),4);
 c.put(uint64_t(s.tx[3].type),1);
 c.put(uint64_t(s.tx[3].ctrl),1);
 c.put(uint64_t(s.tx[3].ls),1);
 c.put(uint64_t(s.tx[3].bytes),2);
 c.put(uint64_t(s.tx[3].ok),1);
 if(s.tx[3].planned>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[3].planned),5);
 if(s.tx[3].actual>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[3].actual),5);
 if(s.tx[3].status>0xffffffffffULL)return false;
 c.put(uint64_t(s.tx[3].status),5);
 c.delta(s.tx[3].begin_us,s.begin_us);
 c.delta(s.tx[3].done_us,s.begin_us);
 c.put(uint64_t(s.tx[3].lead_start_us),4);
 c.put(uint64_t(s.tx[3].lead_arm_us),4);
 c.put(uint64_t(s.tx[3].tx_delta_ticks),4);
 c.put(uint64_t(s.tx[3].prepare_us),4);
 c.put(uint64_t(s.tx[3].wait_us),4);
 c.put(uint64_t(s.tx[3].power_atten_x2),1);
 c.put(uint64_t(s.tx[3].power_octet),1);
 c.put(uint64_t(s.tx[3].power_reg),4);
 c.put(uint64_t(s.tx[3].power_read),4);
 c.put(uint64_t(s.tx[3].power_ok),1);
 c.put(uint64_t(s.tx[3].power_apply_us),4);
 c.put(uint64_t(s.response.bytes),2);
 if(s.response.hw>0xffffffffffULL)return false;
 c.put(uint64_t(s.response.hw),5);
 if(s.response.raw_hw>0xffffffffffULL)return false;
 c.put(uint64_t(s.response.raw_hw),5);
 c.delta(s.response.esp_us,s.begin_us);
 c.delta(s.response.arm_us,s.begin_us);
 c.delta(s.response.switch_us,s.begin_us);
 if(s.response.status>0xffffffffffULL)return false;
 c.put(uint64_t(s.response.status),5);
 c.put(uint64_t(s.response.arm_lead_us),4);
 c.put(uint64_t(s.response.preamble_margin_us),4);
 c.put(uint64_t(s.response.fetch_us),4);
 c.put(uint64_t(s.response.diag_us),4);
 c.put(uint64_t(s.response.detect_lag_us),4);
 c.put(uint64_t(s.response.observed_arm_to_rmarker_us),4);
 c.put(uint64_t(s.response.ci_raw),4);
 c.put(uint64_t(s.response.lde_adjust_ticks),8);
 c.put(uint64_t(s.response.fp_raw),2);
 c.put(uint64_t(s.response.nacc),2);
 c.put(uint64_t(s.response.cir_pwr),2);
 c.put(uint64_t(s.response.f1),2);
 c.put(uint64_t(s.response.f2),2);
 c.put(uint64_t(s.response.f3),2);
 c.put(uint64_t(s.response.noise),2);
 c.put(uint64_t(s.response.ttcki),4);
 c.put(uint64_t(s.response.ttcko),8);
 c.put(s.ok|(s.fast_valid<<1),1);
 for(unsigned i=0;i<40;i++)c.put(uint8_t(s.failure[i]),1);
 for(unsigned i=0;i<4;i++){if(s.fast[i]>0xffffffffffULL)return false;c.put(s.fast[i],5);}
 c.put(s.response.received|(s.response.diag<<1)|(s.response.lde_done<<2),1);
 for(unsigned i=0;i<52;i++)c.put(s.response.raw_air[i],1);
 return c.ok&&c.pos==REMOTE_COMPACT_BYTES;
}
static bool remoteDecode(const RemoteCompactRecord& src,RemoteAnchorRecord& s){
 s=RemoteAnchorRecord{};RemoteCodec c{nullptr,src.data};
 s.txn=decltype(s.txn)(c.get(4));
 s.begin_us=decltype(s.begin_us)(c.get(8));
 s.end_us=c.time(s.begin_us);
 s.ntx=decltype(s.ntx)(c.get(1));
 s.nrx=decltype(s.nrx)(c.get(1));
 s.tx[0].type=decltype(s.tx[0].type)(c.get(1));
 s.tx[0].ctrl=decltype(s.tx[0].ctrl)(c.get(1));
 s.tx[0].ls=decltype(s.tx[0].ls)(c.get(1));
 s.tx[0].bytes=decltype(s.tx[0].bytes)(c.get(2));
 s.tx[0].ok=decltype(s.tx[0].ok)(c.get(1));
 s.tx[0].planned=decltype(s.tx[0].planned)(c.get(5));
 s.tx[0].actual=decltype(s.tx[0].actual)(c.get(5));
 s.tx[0].status=decltype(s.tx[0].status)(c.get(5));
 s.tx[0].begin_us=c.time(s.begin_us);
 s.tx[0].done_us=c.time(s.begin_us);
 s.tx[0].lead_start_us=decltype(s.tx[0].lead_start_us)(c.get(4));
 s.tx[0].lead_arm_us=decltype(s.tx[0].lead_arm_us)(c.get(4));
 s.tx[0].tx_delta_ticks=decltype(s.tx[0].tx_delta_ticks)(c.get(4));
 s.tx[0].prepare_us=decltype(s.tx[0].prepare_us)(c.get(4));
 s.tx[0].wait_us=decltype(s.tx[0].wait_us)(c.get(4));
 s.tx[0].power_atten_x2=decltype(s.tx[0].power_atten_x2)(c.get(1));
 s.tx[0].power_octet=decltype(s.tx[0].power_octet)(c.get(1));
 s.tx[0].power_reg=decltype(s.tx[0].power_reg)(c.get(4));
 s.tx[0].power_read=decltype(s.tx[0].power_read)(c.get(4));
 s.tx[0].power_ok=decltype(s.tx[0].power_ok)(c.get(1));
 s.tx[0].power_apply_us=decltype(s.tx[0].power_apply_us)(c.get(4));
 s.tx[1].type=decltype(s.tx[1].type)(c.get(1));
 s.tx[1].ctrl=decltype(s.tx[1].ctrl)(c.get(1));
 s.tx[1].ls=decltype(s.tx[1].ls)(c.get(1));
 s.tx[1].bytes=decltype(s.tx[1].bytes)(c.get(2));
 s.tx[1].ok=decltype(s.tx[1].ok)(c.get(1));
 s.tx[1].planned=decltype(s.tx[1].planned)(c.get(5));
 s.tx[1].actual=decltype(s.tx[1].actual)(c.get(5));
 s.tx[1].status=decltype(s.tx[1].status)(c.get(5));
 s.tx[1].begin_us=c.time(s.begin_us);
 s.tx[1].done_us=c.time(s.begin_us);
 s.tx[1].lead_start_us=decltype(s.tx[1].lead_start_us)(c.get(4));
 s.tx[1].lead_arm_us=decltype(s.tx[1].lead_arm_us)(c.get(4));
 s.tx[1].tx_delta_ticks=decltype(s.tx[1].tx_delta_ticks)(c.get(4));
 s.tx[1].prepare_us=decltype(s.tx[1].prepare_us)(c.get(4));
 s.tx[1].wait_us=decltype(s.tx[1].wait_us)(c.get(4));
 s.tx[1].power_atten_x2=decltype(s.tx[1].power_atten_x2)(c.get(1));
 s.tx[1].power_octet=decltype(s.tx[1].power_octet)(c.get(1));
 s.tx[1].power_reg=decltype(s.tx[1].power_reg)(c.get(4));
 s.tx[1].power_read=decltype(s.tx[1].power_read)(c.get(4));
 s.tx[1].power_ok=decltype(s.tx[1].power_ok)(c.get(1));
 s.tx[1].power_apply_us=decltype(s.tx[1].power_apply_us)(c.get(4));
 s.tx[2].type=decltype(s.tx[2].type)(c.get(1));
 s.tx[2].ctrl=decltype(s.tx[2].ctrl)(c.get(1));
 s.tx[2].ls=decltype(s.tx[2].ls)(c.get(1));
 s.tx[2].bytes=decltype(s.tx[2].bytes)(c.get(2));
 s.tx[2].ok=decltype(s.tx[2].ok)(c.get(1));
 s.tx[2].planned=decltype(s.tx[2].planned)(c.get(5));
 s.tx[2].actual=decltype(s.tx[2].actual)(c.get(5));
 s.tx[2].status=decltype(s.tx[2].status)(c.get(5));
 s.tx[2].begin_us=c.time(s.begin_us);
 s.tx[2].done_us=c.time(s.begin_us);
 s.tx[2].lead_start_us=decltype(s.tx[2].lead_start_us)(c.get(4));
 s.tx[2].lead_arm_us=decltype(s.tx[2].lead_arm_us)(c.get(4));
 s.tx[2].tx_delta_ticks=decltype(s.tx[2].tx_delta_ticks)(c.get(4));
 s.tx[2].prepare_us=decltype(s.tx[2].prepare_us)(c.get(4));
 s.tx[2].wait_us=decltype(s.tx[2].wait_us)(c.get(4));
 s.tx[2].power_atten_x2=decltype(s.tx[2].power_atten_x2)(c.get(1));
 s.tx[2].power_octet=decltype(s.tx[2].power_octet)(c.get(1));
 s.tx[2].power_reg=decltype(s.tx[2].power_reg)(c.get(4));
 s.tx[2].power_read=decltype(s.tx[2].power_read)(c.get(4));
 s.tx[2].power_ok=decltype(s.tx[2].power_ok)(c.get(1));
 s.tx[2].power_apply_us=decltype(s.tx[2].power_apply_us)(c.get(4));
 s.tx[3].type=decltype(s.tx[3].type)(c.get(1));
 s.tx[3].ctrl=decltype(s.tx[3].ctrl)(c.get(1));
 s.tx[3].ls=decltype(s.tx[3].ls)(c.get(1));
 s.tx[3].bytes=decltype(s.tx[3].bytes)(c.get(2));
 s.tx[3].ok=decltype(s.tx[3].ok)(c.get(1));
 s.tx[3].planned=decltype(s.tx[3].planned)(c.get(5));
 s.tx[3].actual=decltype(s.tx[3].actual)(c.get(5));
 s.tx[3].status=decltype(s.tx[3].status)(c.get(5));
 s.tx[3].begin_us=c.time(s.begin_us);
 s.tx[3].done_us=c.time(s.begin_us);
 s.tx[3].lead_start_us=decltype(s.tx[3].lead_start_us)(c.get(4));
 s.tx[3].lead_arm_us=decltype(s.tx[3].lead_arm_us)(c.get(4));
 s.tx[3].tx_delta_ticks=decltype(s.tx[3].tx_delta_ticks)(c.get(4));
 s.tx[3].prepare_us=decltype(s.tx[3].prepare_us)(c.get(4));
 s.tx[3].wait_us=decltype(s.tx[3].wait_us)(c.get(4));
 s.tx[3].power_atten_x2=decltype(s.tx[3].power_atten_x2)(c.get(1));
 s.tx[3].power_octet=decltype(s.tx[3].power_octet)(c.get(1));
 s.tx[3].power_reg=decltype(s.tx[3].power_reg)(c.get(4));
 s.tx[3].power_read=decltype(s.tx[3].power_read)(c.get(4));
 s.tx[3].power_ok=decltype(s.tx[3].power_ok)(c.get(1));
 s.tx[3].power_apply_us=decltype(s.tx[3].power_apply_us)(c.get(4));
 s.response.bytes=decltype(s.response.bytes)(c.get(2));
 s.response.hw=decltype(s.response.hw)(c.get(5));
 s.response.raw_hw=decltype(s.response.raw_hw)(c.get(5));
 s.response.esp_us=c.time(s.begin_us);
 s.response.arm_us=c.time(s.begin_us);
 s.response.switch_us=c.time(s.begin_us);
 s.response.status=decltype(s.response.status)(c.get(5));
 s.response.arm_lead_us=decltype(s.response.arm_lead_us)(c.get(4));
 s.response.preamble_margin_us=decltype(s.response.preamble_margin_us)(c.get(4));
 s.response.fetch_us=decltype(s.response.fetch_us)(c.get(4));
 s.response.diag_us=decltype(s.response.diag_us)(c.get(4));
 s.response.detect_lag_us=decltype(s.response.detect_lag_us)(c.get(4));
 s.response.observed_arm_to_rmarker_us=decltype(s.response.observed_arm_to_rmarker_us)(c.get(4));
 s.response.ci_raw=decltype(s.response.ci_raw)(c.get(4));
 s.response.lde_adjust_ticks=decltype(s.response.lde_adjust_ticks)(c.get(8));
 s.response.fp_raw=decltype(s.response.fp_raw)(c.get(2));
 s.response.nacc=decltype(s.response.nacc)(c.get(2));
 s.response.cir_pwr=decltype(s.response.cir_pwr)(c.get(2));
 s.response.f1=decltype(s.response.f1)(c.get(2));
 s.response.f2=decltype(s.response.f2)(c.get(2));
 s.response.f3=decltype(s.response.f3)(c.get(2));
 s.response.noise=decltype(s.response.noise)(c.get(2));
 s.response.ttcki=decltype(s.response.ttcki)(c.get(4));
 s.response.ttcko=decltype(s.response.ttcko)(c.get(8));
 uint8_t flags=c.get(1);if(flags&~3U)return false;s.ok=flags&1;s.fast_valid=(flags>>1)&1;
 for(unsigned i=0;i<40;i++)s.failure[i]=char(c.get(1));
 for(unsigned i=0;i<4;i++)s.fast[i]=c.get(5);
 flags=c.get(1);if(flags&~7U)return false;s.response.received=flags&1;s.response.diag=(flags>>1)&1;s.response.lde_done=(flags>>2)&1;
 for(unsigned i=0;i<52;i++)s.response.raw_air[i]=c.get(1);
 return c.ok&&c.pos==REMOTE_COMPACT_BYTES&&s.ntx<=4&&s.nrx<=1;
}
static bool remoteEqual(const RemoteAnchorRecord& a,const RemoteAnchorRecord& b){
 if(a.txn!=b.txn)return false;
 if(a.begin_us!=b.begin_us)return false;
 if(a.end_us!=b.end_us)return false;
 if(a.ntx!=b.ntx)return false;
 if(a.nrx!=b.nrx)return false;
 if(a.tx[0].type!=b.tx[0].type)return false;
 if(a.tx[0].ctrl!=b.tx[0].ctrl)return false;
 if(a.tx[0].ls!=b.tx[0].ls)return false;
 if(a.tx[0].bytes!=b.tx[0].bytes)return false;
 if(a.tx[0].ok!=b.tx[0].ok)return false;
 if(a.tx[0].planned!=b.tx[0].planned)return false;
 if(a.tx[0].actual!=b.tx[0].actual)return false;
 if(a.tx[0].status!=b.tx[0].status)return false;
 if(a.tx[0].begin_us!=b.tx[0].begin_us)return false;
 if(a.tx[0].done_us!=b.tx[0].done_us)return false;
 if(a.tx[0].lead_start_us!=b.tx[0].lead_start_us)return false;
 if(a.tx[0].lead_arm_us!=b.tx[0].lead_arm_us)return false;
 if(a.tx[0].tx_delta_ticks!=b.tx[0].tx_delta_ticks)return false;
 if(a.tx[0].prepare_us!=b.tx[0].prepare_us)return false;
 if(a.tx[0].wait_us!=b.tx[0].wait_us)return false;
 if(a.tx[0].power_atten_x2!=b.tx[0].power_atten_x2)return false;
 if(a.tx[0].power_octet!=b.tx[0].power_octet)return false;
 if(a.tx[0].power_reg!=b.tx[0].power_reg)return false;
 if(a.tx[0].power_read!=b.tx[0].power_read)return false;
 if(a.tx[0].power_ok!=b.tx[0].power_ok)return false;
 if(a.tx[0].power_apply_us!=b.tx[0].power_apply_us)return false;
 if(a.tx[1].type!=b.tx[1].type)return false;
 if(a.tx[1].ctrl!=b.tx[1].ctrl)return false;
 if(a.tx[1].ls!=b.tx[1].ls)return false;
 if(a.tx[1].bytes!=b.tx[1].bytes)return false;
 if(a.tx[1].ok!=b.tx[1].ok)return false;
 if(a.tx[1].planned!=b.tx[1].planned)return false;
 if(a.tx[1].actual!=b.tx[1].actual)return false;
 if(a.tx[1].status!=b.tx[1].status)return false;
 if(a.tx[1].begin_us!=b.tx[1].begin_us)return false;
 if(a.tx[1].done_us!=b.tx[1].done_us)return false;
 if(a.tx[1].lead_start_us!=b.tx[1].lead_start_us)return false;
 if(a.tx[1].lead_arm_us!=b.tx[1].lead_arm_us)return false;
 if(a.tx[1].tx_delta_ticks!=b.tx[1].tx_delta_ticks)return false;
 if(a.tx[1].prepare_us!=b.tx[1].prepare_us)return false;
 if(a.tx[1].wait_us!=b.tx[1].wait_us)return false;
 if(a.tx[1].power_atten_x2!=b.tx[1].power_atten_x2)return false;
 if(a.tx[1].power_octet!=b.tx[1].power_octet)return false;
 if(a.tx[1].power_reg!=b.tx[1].power_reg)return false;
 if(a.tx[1].power_read!=b.tx[1].power_read)return false;
 if(a.tx[1].power_ok!=b.tx[1].power_ok)return false;
 if(a.tx[1].power_apply_us!=b.tx[1].power_apply_us)return false;
 if(a.tx[2].type!=b.tx[2].type)return false;
 if(a.tx[2].ctrl!=b.tx[2].ctrl)return false;
 if(a.tx[2].ls!=b.tx[2].ls)return false;
 if(a.tx[2].bytes!=b.tx[2].bytes)return false;
 if(a.tx[2].ok!=b.tx[2].ok)return false;
 if(a.tx[2].planned!=b.tx[2].planned)return false;
 if(a.tx[2].actual!=b.tx[2].actual)return false;
 if(a.tx[2].status!=b.tx[2].status)return false;
 if(a.tx[2].begin_us!=b.tx[2].begin_us)return false;
 if(a.tx[2].done_us!=b.tx[2].done_us)return false;
 if(a.tx[2].lead_start_us!=b.tx[2].lead_start_us)return false;
 if(a.tx[2].lead_arm_us!=b.tx[2].lead_arm_us)return false;
 if(a.tx[2].tx_delta_ticks!=b.tx[2].tx_delta_ticks)return false;
 if(a.tx[2].prepare_us!=b.tx[2].prepare_us)return false;
 if(a.tx[2].wait_us!=b.tx[2].wait_us)return false;
 if(a.tx[2].power_atten_x2!=b.tx[2].power_atten_x2)return false;
 if(a.tx[2].power_octet!=b.tx[2].power_octet)return false;
 if(a.tx[2].power_reg!=b.tx[2].power_reg)return false;
 if(a.tx[2].power_read!=b.tx[2].power_read)return false;
 if(a.tx[2].power_ok!=b.tx[2].power_ok)return false;
 if(a.tx[2].power_apply_us!=b.tx[2].power_apply_us)return false;
 if(a.tx[3].type!=b.tx[3].type)return false;
 if(a.tx[3].ctrl!=b.tx[3].ctrl)return false;
 if(a.tx[3].ls!=b.tx[3].ls)return false;
 if(a.tx[3].bytes!=b.tx[3].bytes)return false;
 if(a.tx[3].ok!=b.tx[3].ok)return false;
 if(a.tx[3].planned!=b.tx[3].planned)return false;
 if(a.tx[3].actual!=b.tx[3].actual)return false;
 if(a.tx[3].status!=b.tx[3].status)return false;
 if(a.tx[3].begin_us!=b.tx[3].begin_us)return false;
 if(a.tx[3].done_us!=b.tx[3].done_us)return false;
 if(a.tx[3].lead_start_us!=b.tx[3].lead_start_us)return false;
 if(a.tx[3].lead_arm_us!=b.tx[3].lead_arm_us)return false;
 if(a.tx[3].tx_delta_ticks!=b.tx[3].tx_delta_ticks)return false;
 if(a.tx[3].prepare_us!=b.tx[3].prepare_us)return false;
 if(a.tx[3].wait_us!=b.tx[3].wait_us)return false;
 if(a.tx[3].power_atten_x2!=b.tx[3].power_atten_x2)return false;
 if(a.tx[3].power_octet!=b.tx[3].power_octet)return false;
 if(a.tx[3].power_reg!=b.tx[3].power_reg)return false;
 if(a.tx[3].power_read!=b.tx[3].power_read)return false;
 if(a.tx[3].power_ok!=b.tx[3].power_ok)return false;
 if(a.tx[3].power_apply_us!=b.tx[3].power_apply_us)return false;
 if(a.response.bytes!=b.response.bytes)return false;
 if(a.response.hw!=b.response.hw)return false;
 if(a.response.raw_hw!=b.response.raw_hw)return false;
 if(a.response.esp_us!=b.response.esp_us)return false;
 if(a.response.arm_us!=b.response.arm_us)return false;
 if(a.response.switch_us!=b.response.switch_us)return false;
 if(a.response.status!=b.response.status)return false;
 if(a.response.arm_lead_us!=b.response.arm_lead_us)return false;
 if(a.response.preamble_margin_us!=b.response.preamble_margin_us)return false;
 if(a.response.fetch_us!=b.response.fetch_us)return false;
 if(a.response.diag_us!=b.response.diag_us)return false;
 if(a.response.detect_lag_us!=b.response.detect_lag_us)return false;
 if(a.response.observed_arm_to_rmarker_us!=b.response.observed_arm_to_rmarker_us)return false;
 if(a.response.ci_raw!=b.response.ci_raw)return false;
 if(a.response.lde_adjust_ticks!=b.response.lde_adjust_ticks)return false;
 if(a.response.fp_raw!=b.response.fp_raw)return false;
 if(a.response.nacc!=b.response.nacc)return false;
 if(a.response.cir_pwr!=b.response.cir_pwr)return false;
 if(a.response.f1!=b.response.f1)return false;
 if(a.response.f2!=b.response.f2)return false;
 if(a.response.f3!=b.response.f3)return false;
 if(a.response.noise!=b.response.noise)return false;
 if(a.response.ttcki!=b.response.ttcki)return false;
 if(a.response.ttcko!=b.response.ttcko)return false;
 return a.ok==b.ok&&a.fast_valid==b.fast_valid&&memcmp(a.failure,b.failure,40)==0&&memcmp(a.fast,b.fast,32)==0&&
 a.response.received==b.response.received&&a.response.diag==b.response.diag&&a.response.lde_done==b.response.lde_done&&memcmp(a.response.raw_air,b.response.raw_air,52)==0;
}
static bool remoteCodecSelfTest(){
 uint32_t seed=0x31415926;auto rnd=[&](){seed=seed*1664525UL+1013904223UL;return seed;};
 for(unsigned test=0;test<1000;test++){RemoteAnchorRecord a{},b{};RemoteCompactRecord packed{};
 a.begin_us=10000000000ULL+rnd();
 a.txn=decltype(a.txn)(rnd());
 a.end_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.ntx=decltype(a.ntx)(rnd());
 a.nrx=decltype(a.nrx)(rnd());
 a.tx[0].type=decltype(a.tx[0].type)(rnd());
 a.tx[0].ctrl=decltype(a.tx[0].ctrl)(rnd());
 a.tx[0].ls=decltype(a.tx[0].ls)(rnd());
 a.tx[0].bytes=decltype(a.tx[0].bytes)(rnd());
 a.tx[0].ok=decltype(a.tx[0].ok)(rnd());
 a.tx[0].planned=decltype(a.tx[0].planned)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[0].actual=decltype(a.tx[0].actual)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[0].status=decltype(a.tx[0].status)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[0].begin_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[0].done_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[0].lead_start_us=decltype(a.tx[0].lead_start_us)(rnd());
 a.tx[0].lead_arm_us=decltype(a.tx[0].lead_arm_us)(rnd());
 a.tx[0].tx_delta_ticks=decltype(a.tx[0].tx_delta_ticks)(rnd());
 a.tx[0].prepare_us=decltype(a.tx[0].prepare_us)(rnd());
 a.tx[0].wait_us=decltype(a.tx[0].wait_us)(rnd());
 a.tx[0].power_atten_x2=decltype(a.tx[0].power_atten_x2)(rnd());
 a.tx[0].power_octet=decltype(a.tx[0].power_octet)(rnd());
 a.tx[0].power_reg=decltype(a.tx[0].power_reg)(rnd());
 a.tx[0].power_read=decltype(a.tx[0].power_read)(rnd());
 a.tx[0].power_ok=decltype(a.tx[0].power_ok)(rnd());
 a.tx[0].power_apply_us=decltype(a.tx[0].power_apply_us)(rnd());
 a.tx[1].type=decltype(a.tx[1].type)(rnd());
 a.tx[1].ctrl=decltype(a.tx[1].ctrl)(rnd());
 a.tx[1].ls=decltype(a.tx[1].ls)(rnd());
 a.tx[1].bytes=decltype(a.tx[1].bytes)(rnd());
 a.tx[1].ok=decltype(a.tx[1].ok)(rnd());
 a.tx[1].planned=decltype(a.tx[1].planned)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[1].actual=decltype(a.tx[1].actual)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[1].status=decltype(a.tx[1].status)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[1].begin_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[1].done_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[1].lead_start_us=decltype(a.tx[1].lead_start_us)(rnd());
 a.tx[1].lead_arm_us=decltype(a.tx[1].lead_arm_us)(rnd());
 a.tx[1].tx_delta_ticks=decltype(a.tx[1].tx_delta_ticks)(rnd());
 a.tx[1].prepare_us=decltype(a.tx[1].prepare_us)(rnd());
 a.tx[1].wait_us=decltype(a.tx[1].wait_us)(rnd());
 a.tx[1].power_atten_x2=decltype(a.tx[1].power_atten_x2)(rnd());
 a.tx[1].power_octet=decltype(a.tx[1].power_octet)(rnd());
 a.tx[1].power_reg=decltype(a.tx[1].power_reg)(rnd());
 a.tx[1].power_read=decltype(a.tx[1].power_read)(rnd());
 a.tx[1].power_ok=decltype(a.tx[1].power_ok)(rnd());
 a.tx[1].power_apply_us=decltype(a.tx[1].power_apply_us)(rnd());
 a.tx[2].type=decltype(a.tx[2].type)(rnd());
 a.tx[2].ctrl=decltype(a.tx[2].ctrl)(rnd());
 a.tx[2].ls=decltype(a.tx[2].ls)(rnd());
 a.tx[2].bytes=decltype(a.tx[2].bytes)(rnd());
 a.tx[2].ok=decltype(a.tx[2].ok)(rnd());
 a.tx[2].planned=decltype(a.tx[2].planned)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[2].actual=decltype(a.tx[2].actual)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[2].status=decltype(a.tx[2].status)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[2].begin_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[2].done_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[2].lead_start_us=decltype(a.tx[2].lead_start_us)(rnd());
 a.tx[2].lead_arm_us=decltype(a.tx[2].lead_arm_us)(rnd());
 a.tx[2].tx_delta_ticks=decltype(a.tx[2].tx_delta_ticks)(rnd());
 a.tx[2].prepare_us=decltype(a.tx[2].prepare_us)(rnd());
 a.tx[2].wait_us=decltype(a.tx[2].wait_us)(rnd());
 a.tx[2].power_atten_x2=decltype(a.tx[2].power_atten_x2)(rnd());
 a.tx[2].power_octet=decltype(a.tx[2].power_octet)(rnd());
 a.tx[2].power_reg=decltype(a.tx[2].power_reg)(rnd());
 a.tx[2].power_read=decltype(a.tx[2].power_read)(rnd());
 a.tx[2].power_ok=decltype(a.tx[2].power_ok)(rnd());
 a.tx[2].power_apply_us=decltype(a.tx[2].power_apply_us)(rnd());
 a.tx[3].type=decltype(a.tx[3].type)(rnd());
 a.tx[3].ctrl=decltype(a.tx[3].ctrl)(rnd());
 a.tx[3].ls=decltype(a.tx[3].ls)(rnd());
 a.tx[3].bytes=decltype(a.tx[3].bytes)(rnd());
 a.tx[3].ok=decltype(a.tx[3].ok)(rnd());
 a.tx[3].planned=decltype(a.tx[3].planned)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[3].actual=decltype(a.tx[3].actual)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[3].status=decltype(a.tx[3].status)((uint64_t(rnd())<<8)|(rnd()&255));
 a.tx[3].begin_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[3].done_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.tx[3].lead_start_us=decltype(a.tx[3].lead_start_us)(rnd());
 a.tx[3].lead_arm_us=decltype(a.tx[3].lead_arm_us)(rnd());
 a.tx[3].tx_delta_ticks=decltype(a.tx[3].tx_delta_ticks)(rnd());
 a.tx[3].prepare_us=decltype(a.tx[3].prepare_us)(rnd());
 a.tx[3].wait_us=decltype(a.tx[3].wait_us)(rnd());
 a.tx[3].power_atten_x2=decltype(a.tx[3].power_atten_x2)(rnd());
 a.tx[3].power_octet=decltype(a.tx[3].power_octet)(rnd());
 a.tx[3].power_reg=decltype(a.tx[3].power_reg)(rnd());
 a.tx[3].power_read=decltype(a.tx[3].power_read)(rnd());
 a.tx[3].power_ok=decltype(a.tx[3].power_ok)(rnd());
 a.tx[3].power_apply_us=decltype(a.tx[3].power_apply_us)(rnd());
 a.response.bytes=decltype(a.response.bytes)(rnd());
 a.response.hw=decltype(a.response.hw)((uint64_t(rnd())<<8)|(rnd()&255));
 a.response.raw_hw=decltype(a.response.raw_hw)((uint64_t(rnd())<<8)|(rnd()&255));
 a.response.esp_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.response.arm_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.response.switch_us=(test%4==0)?0:a.begin_us+int64_t(int32_t(rnd())/2);
 a.response.status=decltype(a.response.status)((uint64_t(rnd())<<8)|(rnd()&255));
 a.response.arm_lead_us=decltype(a.response.arm_lead_us)(rnd());
 a.response.preamble_margin_us=decltype(a.response.preamble_margin_us)(rnd());
 a.response.fetch_us=decltype(a.response.fetch_us)(rnd());
 a.response.diag_us=decltype(a.response.diag_us)(rnd());
 a.response.detect_lag_us=decltype(a.response.detect_lag_us)(rnd());
 a.response.observed_arm_to_rmarker_us=decltype(a.response.observed_arm_to_rmarker_us)(rnd());
 a.response.ci_raw=decltype(a.response.ci_raw)(rnd());
 a.response.lde_adjust_ticks=decltype(a.response.lde_adjust_ticks)(rnd());
 a.response.fp_raw=decltype(a.response.fp_raw)(rnd());
 a.response.nacc=decltype(a.response.nacc)(rnd());
 a.response.cir_pwr=decltype(a.response.cir_pwr)(rnd());
 a.response.f1=decltype(a.response.f1)(rnd());
 a.response.f2=decltype(a.response.f2)(rnd());
 a.response.f3=decltype(a.response.f3)(rnd());
 a.response.noise=decltype(a.response.noise)(rnd());
 a.response.ttcki=decltype(a.response.ttcki)(rnd());
 a.response.ttcko=decltype(a.response.ttcko)(rnd());
 a.ntx=test%5;a.nrx=test%2;a.ok=test%2;a.fast_valid=(test/2)%2;
 for(unsigned i=0;i<40;i++)a.failure[i]=char(rnd());for(unsigned i=0;i<52;i++)a.response.raw_air[i]=rnd();
 for(unsigned i=0;i<4;i++)a.fast[i]=(uint64_t(rnd())<<8)|(rnd()&255);
 a.response.received=test%2;a.response.diag=(test/2)%2;a.response.lde_done=(test/3)%2;
 if(!remoteEncode(a,packed)||!remoteDecode(packed,b)||!remoteEqual(a,b))return false;
 }
 RemoteAnchorRecord a{},b{};RemoteCompactRecord p{};a.begin_us=3000000000ULL;
 a.end_us=a.begin_us+2147483647ULL;if(!remoteEncode(a,p)||!remoteDecode(p,b)||!remoteEqual(a,b))return false;
 a.end_us=a.begin_us-2147483647ULL;if(!remoteEncode(a,p)||!remoteDecode(p,b)||!remoteEqual(a,b))return false;
 a.end_us=a.begin_us+2147483648ULL;if(remoteEncode(a,p))return false;
 a.end_us=0;a.fast[0]=0xffffffffffULL;if(!remoteEncode(a,p)||!remoteDecode(p,b)||!remoteEqual(a,b))return false;
 a.fast[0]=0x10000000000ULL;if(remoteEncode(a,p))return false;
 return true;
}
